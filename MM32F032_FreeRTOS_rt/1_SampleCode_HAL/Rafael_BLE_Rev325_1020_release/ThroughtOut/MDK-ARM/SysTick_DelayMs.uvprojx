# Keil uVision project SysTick_DelayMs.uvprojx, settings and files
target MM32F032R8T6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F032R8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SysTick_DelayMs +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32F032xx_s\HAL_lib\inc;..\..\..\..\3_Device\MM32F032xx_s\Include;..\Peripheral\inc;..\BSP\inc;..\APP\inc;..\FreeRTOS\FreeRTOS_cfg;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM0;..\FreeRTOS\src;..\FreeRTOS\include;..\BSP\inc;..\RF_Stack\porting;..\RF_Stack\porting\rf_porting;..\RF_Stack\source;..\RF_Stack\include;..\RF_Stack\include\rf_include;..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../3_Device/MM32F032xx_s/Source/: system_MM32F032xx_s.c
    ../../../../3_Device/MM32F032xx_s/Source/KEIL_StartAsm/: startup_MM32F032xx_s_KEIL.s
  group APP
    ../APP/: main.c user.c
    ../FreeRTOS/FreeRTOS_cfg/: FreeRTOSConfig.h
  group BSP
    ../BSP/: bsp_led.c spi.c systick.c uart.c
  group HAL_LIB
    ../../../../3_Device/MM32F032xx_s/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_crc.c HAL_dbg.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_ver.c HAL_wwdg.c
  group README
    ../: readme.txt
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM0/: port.c
  group Porting
    ../RF_Stack/porting/: mcu_definition.h porting_flash.c porting_misc.c porting_spi.c
    ../RF_Stack/porting/rf_porting/: porting_LLtimer.c
  group RF_Source
    ../RF_Stack/source/: bonding_storage.c profile_tab.c Rafael_BLE_MM32F032xx_s.lib
